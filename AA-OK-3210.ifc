Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: C:\Users\AA\AA TRAPPEN\AA-Trappen - Algemeen\2022\WVB OPDRACHTEN 2022\0000 - Voorstel\000-AA_TRAPPEN_WEBSITE\Onderkwart\AA-OK-3210\AA-OK-3210.ifc
Time: 2022-10-03T07:54:44
Written by: IfcOpenShell 0.5.0-dev
Made in: IfcOpenShell 0.5.0-dev

# IfcStair, Trap 1
In: BuildingStorey
ShapeType: USERDEFINED

# IfcStairFlight, Trap 1
In: BuildingStorey
NumberOfRiser: 1; NumberOfTreads: 16; RiserHeight: 185 mm; TreadLength: 220 mm
